Commit message: backup

File: robots_mj/fr3_with_camera_and_bounding_boxes.urdf (robot description, URDF)
Before this commit: robot fr3, 21 links, 20 joints
Links:
- link fr3_camera: mass 0.072 -> 1e-10
- link fr3_hand_tcp: mass 1e-5 -> 1e-10
- link fr3_link8: mass 1e-5 -> 1e-10
